# IAR project driverlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  ICCARM.CCDefines: CC2538_USE_ALTERNATE_INTERRUPT_MAP
  ICCARM.CCIncludePath2: ..\..\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\inc
  ILINK.IlinkOutputFile: driverlib.out
configuration Release (ARM)
  as the first configuration, except:
  group source
    ../../source/: adc.c aes.c ccm.c cpu.c debug.c flash.c gpio.c gptimer.c i2c.c interrupt.c ioc.c pka.c sha256.c sleepmode.c ssi.c sys_ctrl.c systick.c uart.c udma.c watchdog.c
