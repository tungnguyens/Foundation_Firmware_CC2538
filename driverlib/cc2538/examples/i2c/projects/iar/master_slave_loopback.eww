<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\master_slave_loopback.ewp</path>
  </project>
  <batchBuild/>
</workspace>


