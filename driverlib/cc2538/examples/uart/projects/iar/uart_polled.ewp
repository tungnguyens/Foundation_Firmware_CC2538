# IAR project uart_polled.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; ENABLE_ASSERT; CC2538_USE_ALTERNATE_INTERRUPT_MAP
  ICCARM.CCIncludePath2: ../../../../inc; ../../../../source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart_polled.bin
  ILINK.IlinkOutputFile: uart_polled.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../startup_files/: startup_iar.c
    ../../source/: uart_polled.c
  group driverlib
    ../../../../source/: adc.c cpu.c debug.c flash.c gpio.c gptimer.c i2c.c interrupt.c ioc.c sleepmode.c ssi.c sys_ctrl.c systick.c uart.c udma.c watchdog.c
