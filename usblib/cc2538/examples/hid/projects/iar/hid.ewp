# IAR project hid.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ENABLE_ASSERT; CC2538_USE_ALTERNATE_INTERRUPT_MAP; USB_SETUP_MAX_NUMBER_OF_INTERFACES=5
  ICCARM.CCIncludePath2: ../../../../source/library; ../../../../source/library/cc2538; ../../../../source/class_hid; ../../../../../../driverlib/cc2538/inc; ../../../../../../driverlib/cc2538/source; ../../../../../../bsp/srf06eb_cc2538/drivers/source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: chip=2538
  OBJCOPY.OOCOutputFile: hid.bin
  ILINK.IlinkOutputFile: hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../../source/: main.c
    ../../../startup_files/: startup_iar.c
  group bsp/srf06eb_cc2538
    ../../../../../../bsp/srf06eb_cc2538/drivers/source/: acc_bma250.h acc_srf06eb.c als_sfh5711.h als_srf06eb.c bsp.c bsp.h bsp_key.c bsp_key.h bsp_led.c bsp_led.h bsp_uart.c bsp_uart.h io_pin_int.c io_pin_int.h lcd_dogm128_6.c lcd_dogm128_6.h lcd_dogm128_6_alphabet.c lcd_srf06eb.c sdcard.h sdcard_srf06eb.c
  group driverlib/cc2538
    ../../../../../../driverlib/cc2538/source/: adc.c adc.h bl_commands.h cpu.c cpu.h debug.c debug.h ecc_curveinfo.h flash.c flash.h gpio.c gpio.h gptimer.c gptimer.h i2c.c i2c.h interrupt.c interrupt.h ioc.c ioc.h pka.c pka.h rom.h sleepmode.c sleepmode.h ssi.c ssi.h sys_ctrl.c sys_ctrl.h systick.c systick.h uart.c uart.h udma.c udma.h watchdog.c watchdog.h
  group driverlib/cc2538/inc
    ../../../../../../driverlib/cc2538/inc/: hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
  group usb/class_hid
    ../../../../source/class_hid/: app_usb_descriptor.c app_usb_descriptor.h usb_class_requests.c usb_class_requests.h usb_hid.c usb_hid.h usb_hid_hooks.c usb_hid_reports.c usb_hid_reports.h
  group usb/library
    ../../../../source/library/: hw_usb_aliases.h usb_descriptor_defs.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_in_buffer.c usb_in_buffer.h usb_interrupt.h usb_out_buffer.c usb_out_buffer.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group usb/library/cc2538
    ../../../../source/library/cc2538/: usb.c usb.h usb_firmware_library_headers.h usb_interrupt.c usb_suspend.c
