# IAR project usblib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  ICCARM.IExtraOptions: -f "usblib_iar.cfg"
  ICCARM.CCIncludePath2: ..\..\source\library; ..\..\source\library\cc2538; ..\..\..\..\driverlib\cc2538\inc; ..\..\..\..\driverlib\cc2538\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  ILINK.IlinkOutputFile: usblib.out
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: usblib_iar.cfg
  group source
    ../../source/library/: hw_usb_aliases.h usb_descriptor_defs.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_in_buffer.c usb_in_buffer.h usb_interrupt.h usb_out_buffer.c usb_out_buffer.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group source/cc2538
    ../../source/library/cc2538/: usb.c usb.h usb_firmware_library_headers.h usb_interrupt.c usb_suspend.c
